## boards/shields/metasepia/Kconfig.defconfig
```kconfig
if SHIELD_METASEPIA

config ZMK_KEYBOARD_NAME
    default "Metasepia"
config USB_DEVICE_MANUFACTURER
    default "Zakwaykway"

endif
```
